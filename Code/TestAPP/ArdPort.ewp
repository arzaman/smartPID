# IAR project ArdPort.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD21G18A Atmel ATSAMD21G18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: __SAMD21G18A__; BOARD=SAMD21_XPLAINED_PRO; FEATURE_SERCOM_SYNCBUSY_SCHEME_VERSION_2; F_CPU=48000000L; ARDUINO=10607; ARDUINO_SAMD_ZERO; ARDUINO_ARCH_SAMD; __SAMD21G18A__; USB_VID=0x1B4F; USB_PID=0x8D21; USBCON; USB_MANUFACTURER="Arzaman"; USB_PRODUCT="AB1000"; rHAVE_HWSERIAL0; SSD1306; SAMD21; remSAMD21_64K; boolean=bool
  ICCARM.PreInclude: ABM_Port.h
  ICCARM.CCIncludePath2: ; variants\AB1000\; CMSIS\Include\; arduino\; libraries\U8glib\; libraries\Wire\; libraries\Adafruit_GFX_Library\; libraries\Adafruit_SSD1306\; libraries\SPI\; libraries\ASF\; libraries\I2C_MASTER_DMA\; libraries\ASF\samd21\include\; libraries\OneButton\; libraries\PID\; libraries\RWW_EEPROM\
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: ArdPort.bin
  ILINK.IlinkOutputFile: ArdPort.out
  ILINK.IlinkIcfFile: user_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group (top)
    ./: ABM_Buttons.cpp ABM_Buzzer.cpp ABM_HW_switch.cpp delay.cpp PID_control.cpp ProcessN1.cpp run_mode.cpp Sensors.cpp small_log.cpp storage_var.cpp u8g_port.cpp utlts.cpp
    arduino/USB/: CDC.cpp PluggableUSB.cpp USBCore.cpp
    arduino/: hooks.c main.cpp Reset.cpp RingBuffer.cpp SERCOM.cpp startup.c Uart.cpp wiring.c wiring_analog.c wiring_digital.c wiring_private.c
    libraries/ASF/samd21/source/iar/: startup_samd21.c
    variants/AB1000/: variant.cpp
  group ASF
    libraries/ASF/: clock.c dma.c gclk.c i2c_master.c interrupt_sam_nvic.c pinmux.c sercom_asf.c
  group IAR_lib
    $EW_DIR$/arm/src/lib/: write.c
  group icons
    ./: small_icons.c SmartPID_logo_1bit.c
  group Library
    arduino/: Print.cpp
    libraries/SPI/: SPI.cpp
    libraries/Wire/: Wire.cpp
  group Library/Adafruit_SSD1306
    libraries/Adafruit_GFX_Library/: Adafruit_GFX.cpp
    libraries/Adafruit_SSD1306/: Adafruit_SSD1306.cpp ssd1306_128x64_i2c.cpp
  group Library/I2C_DMA
    libraries/I2C_MASTER_DMA/: oled_dma.c qs_i2c_master_dma.cpp
  group Library/OneButton
    libraries/OneButton/: OneButton.cpp
  group Library/PID
    libraries/PID/: PID_v1.cpp
  group Library/RWW_EEPROM
    libraries/RWW_EEPROM/: bod.c eeprom.c nvm.c wdt.c
  group Library/u8glib
    libraries/U8glib/: u8g_bitmap.c u8g_clip.c u8g_font.c u8g_line.c u8g_ll_api.c u8g_page.c u8g_pb.c u8g_rect.c u8g_state.c
  group Library/u8glib/sfntsrc
    libraries/U8glib/: u8g_font_data.c
  group Library/vsdGUI
    ./: vsd_GUI.cpp vsd_Menu.cpp vsd_ValueList.cpp
  group menu
    ./: menu_connect_log.cpp menu_run_mode.cpp menu_sw_setup.cpp
